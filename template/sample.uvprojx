# Keil uVision project sample.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: sample
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group test
    ./: main.c redirect.c system_ARMCM3.c startup_ARMCM3.s add.s
software components: CMSIS:CORE 5.1.1
